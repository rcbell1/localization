<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_3n_phaselock_sub</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2.395e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_path_str</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'/mnt/ramdisk/'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_path1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>full_path + 'rx1.dat'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_path2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>full_path + 'rx2.dat'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_path3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>full_path + 'rx3.dat'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>full_path</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>data_path_str + tx_loc_str + '/' + rx_samp_rate_str + '/' + test_num_str + '/' </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>high_water_mark</value></param>
<param><key>value</key><value>-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nitems_stop</value></param>
<param><key>value</key><value>np.ceil(sps*(prnLen+nzeros)*npulses_stop*samp_rate/tx_samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>npulses_stop</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nzeros</value></param>
<param><key>value</key><value>3000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prnLen</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_samp_rate_str</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'rfs16'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e6/12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>socket_addr</value></param>
<param><key>value</key><value>'tcp://127.0.0.1:8000'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>span</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>test_num_str</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'1'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_loc_str</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'tx_center'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_samp_rate</value></param>
<param><key>value</key><value>200e6/70</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_path1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_path2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_path3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>int(nitems_stop)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1</value></param>
<param><key>num_items</key><value>int(nitems_stop)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_2</value></param>
<param><key>num_items</key><value>int(nitems_stop)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>3</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>socket_addr</value></param>
<param><key>hwm</key><value>high_water_mark</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>blocks_vector_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_2</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_2</source_block_id><sink_block_id>blocks_vector_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_head_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_head_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
