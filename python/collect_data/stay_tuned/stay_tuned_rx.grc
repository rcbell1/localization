<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>stay_tuned_subscriber</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>head_no</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/rsubbaraman/gitrepos/rx1.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/rsubbaraman/gitrepos/rx2.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>head_no</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>num_items</key><value>head_no</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:6000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
