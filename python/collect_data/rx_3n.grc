<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_3n</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>2.395e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_path_str</value></param>
<param><key>value</key><value>'/mnt/ramdisk/'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>full_path</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>data_path_str + tx_loc_str + '/' + rx_samp_rate_str + '/' + test_num_str + '/' </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>full_path</value></param>
<param><key>value</key><value>''</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>high_water_mark</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>int(nitems_stop)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>high_water_mark</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nitems_stop</value></param>
<param><key>value</key><value>np.ceil(sps*(prnLen+nzeros)*npulses_stop*samp_rate/tx_samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>npulses_stop</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nzeros</value></param>
<param><key>value</key><value>3000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prnLen</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_samp_rate_str</value></param>
<param><key>value</key><value>'rfs16'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e6/12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>socket_addr_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'tcp://127.0.0.1:8000'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>socket_addr_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'tcp://127.0.0.1:8001'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>socket_addr_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'tcp://127.0.0.1:8002'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>span</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>test_num_str</value></param>
<param><key>value</key><value>'1'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_loc_str</value></param>
<param><key>value</key><value>'tx_center'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_samp_rate</value></param>
<param><key>value</key><value>200e6/70</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>full_path + 'rx1.dat'</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>full_path + 'rx2.dat'</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>full_path + 'rx3.dat'</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>int(nitems_stop)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1</value></param>
<param><key>num_items</key><value>int(nitems_stop)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_2</value></param>
<param><key>num_items</key><value>int(nitems_stop)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>200</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0</value></param>
<param><key>length</key><value>200</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0</value></param>
<param><key>length</key><value>200</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>False</value></param>
<param><key>iq_imbal_enb0</key><value>False</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>center_freq</value></param>
<param><key>dc_offs_enb1</key><value>False</value></param>
<param><key>iq_imbal_enb1</key><value>False</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>rx_gain</value></param>
<param><key>ant2</key><value>RX2</value></param>
<param><key>center_freq2</key><value>center_freq</value></param>
<param><key>dc_offs_enb2</key><value>False</value></param>
<param><key>iq_imbal_enb2</key><value>False</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>200e6</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.2,addr1=192.168.11.2,addr2=192.168.12.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>B:0</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>sd_spec1</key><value>B:0</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>clock_source2</key><value>external</value></param>
<param><key>sd_spec2</key><value>B:0</value></param>
<param><key>time_source2</key><value>external</value></param>
<param><key>nchan</key><value>3</value></param>
<param><key>num_mboards</key><value>3</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>True</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>zeromq_rep_sink</key>
<param><key>id</key><value>zeromq_rep_sink_0</value></param>
<param><key>address</key><value>socket_addr_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hwm</key><value>high_water_mark</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_rep_sink</key>
<param><key>id</key><value>zeromq_rep_sink_0_0</value></param>
<param><key>address</key><value>socket_addr_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hwm</key><value>high_water_mark</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_rep_sink</key>
<param><key>id</key><value>zeromq_rep_sink_0_1</value></param>
<param><key>address</key><value>socket_addr_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hwm</key><value>high_water_mark</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>zeromq_rep_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>blocks_vector_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>zeromq_rep_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_2</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_2</source_block_id><sink_block_id>blocks_vector_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_2</source_block_id><sink_block_id>zeromq_rep_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0</source_block_id><sink_block_id>blocks_head_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0</source_block_id><sink_block_id>blocks_head_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>dc_blocker_xx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
